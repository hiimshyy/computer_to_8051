# Keil uVision project Image_video_to_led_matrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Image_video_to_led_matrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: image_video_to_led_matrix.c
